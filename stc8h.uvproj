# Keil uVision project stc8h.uvproj, settings and files
target stc8h (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc8h +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\devices;.\user;.\system;.\INC;.\INC\STC
  group user
    ./user/: main.c
  group devices
    ./devices/: lcd1602.c lcd12864.c I2C.c SPI.c
  group system
    ./system/: clock.c
  group INC
    ./INC/: ABSACC.H ASSERT.H CTYPE.H ERRNO.H FLOAT.H INTRINS.H LIMITS.H MATH.H REG51.H REG52.H RTX51TNY.H SETJMP.H SROM.H STDARG.H STDDEF.H STDIO.H STDLIB.H STRING.H
    ./INC/STC/: STC8.H STC8G.H STC8H.H STC12C5A60S2.H STC12C2052AD.H STC12C5410AD.H STC12C5630AD.H STC15.H STC15F2K60S2.H STC15F104E.H STC89C5xRC.H STC90C5xAD.H
